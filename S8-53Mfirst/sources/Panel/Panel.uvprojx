# Keil uVision project Panel.uvprojx, settings and files
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L063C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Panel
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L063xx
  c include: .\src;..;.\src\Hardware\HAL;..\common\STM32Cube_L0\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\common\STM32Cube_L0\Drivers\CMSIS\Include;..\common\STM32Cube_L0\Drivers\STM32L0xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group HAL
    ../common/STM32Cube_L0/Drivers/STM32L0xx_HAL_Driver/Inc/: stm32l0xx_hal.h stm32l0xx_hal_cortex.h stm32l0xx_hal_dma.h stm32l0xx_hal_gpio.h stm32l0xx_hal_rcc.h stm32l0xx_hal_spi.h stm32l0xx_hal_tim.h
    ../common/STM32Cube_L0/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c
  group src
    ./src/: defines.h HAL.h HAL.cpp HAL_IT.cpp HAL_PINS.cpp HAL_PINS.h HAL_SPI2.cpp Interface.h Interface.cpp Keyboard.h Keyboard.cpp LEDS.h LEDS.cpp main.cpp main.s PowerSupply.h PowerSupply.cpp startup_stm32l063xx.s stm32l0xx_hal_conf.h system_stm32l0xx.c
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L063C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: as above
  output: Panel
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L063xx, DEBUG
  c include: .\src;..\..\sources;.\src\Hardware\HAL;..\common\STM32Cube_L0\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\common\STM32Cube_L0\Drivers\CMSIS\Include;..\common\STM32Cube_L0\Drivers\STM32L0xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
