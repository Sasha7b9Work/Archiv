# Keil uVision project DLoader.uvprojx, settings and files
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DLoader
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx, __cplusplus, LOADER
  c misc: --cpp
  c include: .\src;.\src\libs;.\src\Hardware\HAL;..\common\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\STM32Cube_F4\Drivers\CMSIS\Include;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\common\STM32Cube_F4\Middlewares\Third_Party\FatFs\src\drivers;..\common\Hardware\FDrive;..;..\common\Hardware\FatFS
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\DLoader.sct
  group libs/CMSIS
    ../common/STM32Cube_F4/Drivers/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h
  group libs/FatFS
    ../common/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h
    ../common/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group libs/HAL
    ../common/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_dma.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_hcd.h stm32f4xx_hal_rcc.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_def.h stm32f4xx_ll_usb.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_ltdc.h
    ../common/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_dac.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_ltdc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c
    ../common/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group libs/USBH
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../common/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Hardware
    ../common/Hardware/: Timer_.h Timer_.cpp
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f429xx.s system_stm32f4xx.c
  group Hardware/FatFS
    ../common/Hardware/FatFS/: ffconf.h
  group Hardware/Memory
    ../common/Hardware/Memory/: Sector_.h Sector_.cpp
  group Hardware/HAL
    ./src/Hardware/HAL/: stm32f4xx_hal_conf.h HAL_IT.cpp
    ../common/Hardware/HAL/: HAL_PINS_.h HAL_PINS_.cpp HAL_.h HAL_.cpp HAL_DAC1_.cpp HAL_LTDC_.cpp HAL_ROM_.cpp HAL_TIM2_.cpp HAL_FMC_.cpp HAL_TIM6_.cpp
  group Hardware/FDrive
    ../common/Hardware/FDrive/: USBH_.cpp USBH_.h usbh_conf_.cpp usbh_conf_.h usbh_diskio_.cpp usbh_diskio_.h
    ./src/Hardware/FDrive/: FDrive.cpp FDrive.h
  group src
    ./src/: defines.cpp defines.h main.cpp main.h
    ../common/: defines_.h Log_.cpp Log_.h
  group Display
    ../common/Display/Painter/: Animated_.h Animated_.cpp
    ../common/Display/: Colors_.h Colors_.cpp Colors_stm_.cpp Display_stm_.cpp
    ./src/Display/: Display.h Display.cpp
  group Display/Font
    ../common/Display/Font/: font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc Font_.cpp Font_.h
  group Display/Painter
    ../common/Display/Painter/: Painter_.cpp Painter_.h Primitives_.cpp Primitives_.h Primitives_stm_.cpp Text_.cpp Text_.h
  group Panel
    ./src/Panel/: Panel.h Panel.cpp
  group Settings
    ./src/Settings/: Settings.h Settings.cpp
  group Utils
    ../common/Utils/: StringUtils_.cpp StringUtils_.h Math_.cpp Math_.h
  group Utils/Containers
    ../common/Utils/Containers/: String_.h String_.cpp Buffer_.cpp Buffer_.h Values_.cpp Values_.h
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: DLoader
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx, __cplusplus, LOADER, DEBUG
  c misc: --cpp
  c include: .\src;.\src\libs;.\src\Hardware\HAL;..\common\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\STM32Cube_F4\Drivers\CMSIS\Include;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\common\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\common\STM32Cube_F4\Middlewares\Third_Party\FatFs\src\drivers;..\common\Hardware\FatFS;..\common\Hardware\FDrive;..\..\sources
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\DLoader.sct
