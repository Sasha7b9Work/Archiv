# Keil uVision project ET_ST302_Server.uvproj, settings and files
target Server (ARM-ADS)
  device: STM32F207VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ET_ST302_Server
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\..\..\LIBS\CMSIS;.\src;..\..\..\LIBS\STM32F2xx_StdPeriph_Driver;..\..\..\LIBS\STM32F2x7_ETH_Driver;..\..\..\LIBS\STM32_EVAL;..\..\..\LIBS\lwip-1.4.1\src\include;..\..\..\LIBS\lwip-1.4.1\src\port\STM32F2x7;..\..\..\LIBS\lwip-1.4.1\src\include\ipv4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group system
    ./src/: startup_stm32f2xx.s system_stm32f2xx.c
    ../../../LIBS/CMSIS/: system_stm32f2xx.h core_cm3.c core_cm3.h stm32f2xx.h
  group std_periph
    ../../../LIBS/STM32F2xx_StdPeriph_Driver/: misc.h misc.c stm32f2xx_gpio.c stm32f2xx_gpio.h stm32f2xx_rcc.h stm32f2xx_rcc.c stm32f2xx_exti.h stm32f2xx_exti.c stm32f2xx_dac.h stm32f2xx_dac.c stm32f2xx_tim.h stm32f2xx_tim.c
  group src
    ./src/: stm32f2x7_eth_conf.h stm32f2x7_eth_bsp.c stm32f2x7_eth_bsp.h netconf.c netconf.h stm32f2xx_it.h stm32f2xx_it.c httpd.h httpd.c fs.h fs.c main.h ServerBSD.h ServerBSD.c lwipopts.h main.cpp stm32f2xx_conf.h common.h common.cpp String.cpp String.h Ethernet.h TcpSocket.cpp TcpSocket.h Ethernet.cpp Display.cpp Display.h Color.h Menu.h Menu.cpp
  group eth
    ../../../LIBS/STM32F2x7_ETH_Driver/: stm32f2x7_eth.h stm32f2x7_eth.c
  group stm_eval
    ../../../LIBS/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval.h stm322xg_eval.c
  group lwip
    ../../../LIBS/lwip-1.4.1/src/port/STM32F2x7/Standalone/: ethernetif.h ethernetif.c
    ../../../LIBS/lwip-1.4.1/src/netif/: etharp.c
    ../../../LIBS/lwip-1.4.1/src/include/lwip/: memp.h mem.h tcp.h
    ../../../LIBS/lwip-1.4.1/src/core/: memp.c mem.c tcp.c raw.c udp.c tcp_out.c netif.c pbuf.c dhcp.c def.c timers.c tcp_in.c
    ../../../LIBS/lwip-1.4.1/src/core/ipv4/: ip.c ip_addr.c icmp.c ip_frag.c inet_chksum.c
