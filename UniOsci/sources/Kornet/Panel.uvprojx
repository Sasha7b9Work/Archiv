# Keil uVision project Panel.uvprojx, settings and files
target Panel (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Panel
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,__cplusplus
  c misc: --cpp
  c include: ..\_libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\_libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\_libs\STM32Cube_F4\Drivers\CMSIS\Include;.\Panel;.\Panel\libs;..\common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group HAL
    ../_libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group libs
    ./Panel/libs/: startup_stm32f429xx.s stm32f4xx_hal_conf.h stm32f4xx_it.h system_stm32f4xx.c stm32f4xx_it.cpp stm32f4xx_hal_msp.cpp
  group Display
    ./Panel/Display/: Display.cpp Display.h DisplayTypes.h Painter.cpp Painter.h
  group Display/font
    ./Panel/Display/font/: Font.h font5.inc font8.inc fontUGO.inc fontUGO2.inc Font.cpp
  group Hardware
    ./Panel/Hardware/: Decoder.cpp Decoder.h FSMC.cpp FSMC.h Hardware.cpp Hardware.h Timer.cpp Timer.h
  group Keyboard
    ./Panel/Keyboard/: Controls.h Keyboard.cpp Keyboard.h
  group src
    ./Panel/: defines.h main.cpp
    ../common/: commonDefines.cpp commonDefines.h
