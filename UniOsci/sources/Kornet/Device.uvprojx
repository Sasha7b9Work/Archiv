# Keil uVision project Device.uvprojx, settings and files
target Device (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F437ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Device
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F437xx,__cplusplus
  c misc: --cpp
  c include: ..\_libs\STM32Cube_F4\Drivers\CMSIS\Include;..\_libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\_libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;.\Device;.\Device\libs;..\common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group HAL
    ../_libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_nor.c stm32f4xx_hal_pcd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_tim.c stm32f4xx_ll_usb.c
  group libs
    ./Device/libs/: startup_stm32f437xx.s stm32f4xx_hal_conf.h stm32f4xx_it.h system_stm32f4xx.c stm32f4xx_hal_msp.cpp stm32f4xx_it.cpp
  group Display
    ./Device/Display/: Display.cpp Display.h Grid.cpp Grid.h Painter.cpp Painter.h PainterData.cpp PainterData.h TypeSymbols.h
  group FPGA
    ./Device/FPGA/: AD9286.cpp AD9286.h FPGA.cpp FPGA.h Storage.cpp Storage.h FPGATypes.h
    ../common/FPGA/: FPGAMath.cpp FPGAMath.h
  group Keyboard
    ./Device/Keyboard/: Buttons.h
  group Hardware
    ./Device/Hardware/: Decoder.cpp Decoder.h FLASH.cpp FLASH.h FSMC.cpp FSMC.h GPIO.cpp GPIO.h Hardware.cpp Hardware.h Timer.cpp Timer.h
  group Menu
    ./Device/Menu/: Menu.cpp Menu.h MenuControls.cpp MenuControls.h
  group Menu/Pages
    ./Device/Menu/Pages/: PageChannel.cpp PageDisplay.cpp PageService.cpp PageTester.cpp PageTrig.cpp
  group Multimeter
    ./Device/Multimeter/: Multimeter.cpp Multimeter.h
  group Osci
    ./Device/Osci/: Osci.cpp Osci.h
  group Settings
    ./Device/Settings/: Settings.cpp Settings.h SettingsTypes.h SettingsMath.h SettingsTime.h
  group Tester
    ./Device/Tester/: Tester.cpp Tester.h
  group Utils
    ../common/Utils/: Math.cpp Math.h StringUtils.cpp StringUtils.h Dictionary.cpp Dictionary.h CommonFunctions.cpp CommonFunctions.h
  group src
    ./Device/: defines.h Device.cpp Device.h Log.cpp Log.h main.cpp main.h
    ../common/: commonDefines.cpp
