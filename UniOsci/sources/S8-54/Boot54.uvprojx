# Keil uVision project Boot54.uvprojx, settings and files
target Boot54 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F437ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DeviceBoot
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F437xx, __cplusplus, S8_54
  c misc: --cpp
  c include: ..\_libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\_libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\_libs\STM32Cube_F4\Drivers\CMSIS\Include;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\_libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;.\Boot54;.\Boot54\libs;..\common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Boot54\Boot54.sct
  group FatFS
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group HAL
    ../_libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c
  group USBH
    ../_libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../_libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group src
    ./Boot54/: Boot54.sct defines.h globals.c globals.h main.h main.cpp
  group libs
    ./Boot54/libs/: ffconf.h startup_stm32f437xx.s stm32f4xx_hal_conf.h system_stm32f4xx.c usbh_conf.h usbh_diskio.h stm32f4xx_hal_msp.cpp usbh_conf.cpp usbh_diskio.cpp
  group Display
    ./Boot54/Display/: Colors.h Display.h DisplayTypes.h Painter.h PainterC.h PainterText.h PainterText.cpp Colors.cpp Display.cpp Painter.cpp
  group Display/fonts
    ./Boot54/Display/font/: Font.h font8.inc Font.cpp
  group FlashDrive
    ./Boot54/FlashDrive/: FlashDrive.h FlashDrive.cpp
  group Hardware
    ./Boot54/Hardware/: FLASH.h FSMC.h Hardware.h FLASH.cpp FSMC.cpp Hardware.cpp
    ../common/Hardware/: Timer.cpp Timer.h
  group Panel
    ./Boot54/Panel/: Controls.c Controls.h Panel.h Panel.cpp
  group Settings
    ./Boot54/Settings/: Settings.h SettingsTypes.h Settings.cpp
  group Utils
    ../common/Utils/: StringUtils.cpp StringUtils.h Dictionary.cpp Dictionary.h
  group FPGA
    ./Boot54/FPGA/: FPGATypes.h
